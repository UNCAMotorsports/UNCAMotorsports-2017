File: ESF_Diagrams/Accumulator.sch (KiCad schematic (older format))
At the start: 70 parts

Commit message: ESF Fixes
Parts:
- gave numbers to parts that had none: 70
